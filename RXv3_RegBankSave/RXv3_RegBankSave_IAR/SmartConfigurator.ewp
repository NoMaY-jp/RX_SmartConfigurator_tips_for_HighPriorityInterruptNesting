# IAR project SmartConfigurator.ewp, settings and files
configuration Debug (RX, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCRX.IccLang: 0
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group (top)
    ./: buildinfo.ipcf main.c
